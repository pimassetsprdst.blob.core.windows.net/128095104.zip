Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-23T09:51:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 23 09:51:26 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{EDFE4D1E-6BA5-4293-B3DE-087544D57000}\ifc * Database version: 5507 * Database creation date: Tue Oct 23 09:51:25 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Oct 23 09:51:25 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 23 09:51:25 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: TB-U1.1.1-CG, E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN:TB-U1.1.1-CG:1302675
In: V00
Type - Material: Color RGB 74-138-202, Color RGB 249-249-249, Color RGB 155-163-166
Type - Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm
Type - Dimensions - Depth: 9 mm; Height: 86 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Safe Height: 85 mm; Safe Width: 85 mm; Width: 86 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Type: TB/U1.1.1-CG; Base Family Version: 11.19; Category: EL_BUSSYSTEM_WITH_ADDRESS; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: TB/U1.1.1-CG Control element 1g.; EMCS Version: 4.0; ETIM Article Class: EC000672; Family Version: 11.20; Manufacturer: ABB; Manufacturer URL: https://new.abb.com/products/2CKA006300A1538; MEPcontent Class: CONTROL_UNIT; Model: TB/U1.1.1-CG; OmniClass Number: 23.60.50.00; OmniClass Title: General Purpose Controls; Revit Version: 2017; Type Name: TB-U1.1.1-CG; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Body: Color RGB 249-249-249; Button: Color RGB 74-138-202; Name: Color RGB 155-163-166
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Security Devices; Button 1.1: yes; Button 12: no; Button 12 Horizontal: no; Button 2 Horizontal: no; Button 2 Vertical: no; Button 4: no; Button 8 Vertical: no; Family Name: E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN
Type - Text - Article Description: TB/U1.1.1-CG Control element 1g.; GTIN: 4011395230725; Manufacturer Art. No.: 2CKA006300A1538; Product Line: KNX - User Operation - tacteo - 1 fold
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 0.021435 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000117523 m3
Identity Data - Mark: 1
Other - Family: E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN: TB-U1.1.1-CG; Family and Type: E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN: TB-U1.1.1-CG; Type: E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN: TB-U1.1.1-CG; Type Id: E_Control Unit_MEPcontent_ABB_Tacteo_Control Element_INT-EN: TB-U1.1.1-CG
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Anti-Theft Protection: no
